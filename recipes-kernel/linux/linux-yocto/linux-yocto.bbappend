FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://gcp-dma.cfg"
